File: Lightsaber.sch (EAGLE design)
At the start: 25 parts

Commit message: fixed silkscreen for names/values
Parts:
- renumbered D1 to 1, D10 to 10, D2 to 2, D3 to 3, D4 to 4, D5 to 5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
